# IAR project uCOS-II.ewp, settings and files
configuration SWM181 (ARM, debug)
  General.OGChipSelectEditMenu: SWM181xB Synwit SWM181xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM181_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM181_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM181_StdPeriph_Driver\CSL\SWM181_StdPeriph_Driver; .\APP; .\APP\uCOS; .\APP\uCOS\Ports\ARMv6-M\ARM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: _DLIB_FILE_DESCRIPTOR
  OBJCOPY.OOCOutputFile: uCOS-II.srec
  ILINK.IlinkOutputFile: uCOS-II.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./app/: main.c
  group uCOS
    ./APP/uCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS\Port
    ./APP/uCOS/Ports/ARMv6-M/: os_cpu_c.c
    ./APP/uCOS/Ports/ARMv6-M/IAR/: os_cpu_a.asm
  group CSL\StdPD
    ../../SWM181_StdPeriph_Driver/CSL/SWM181_StdPeriph_Driver/: SWM181_adc.c SWM181_cmp.c SWM181_exti.c SWM181_gpio.c SWM181_i2c.c SWM181_pwm.c SWM181_timr.c SWM181_uart.c SWM181_wdt.c SWM181_can.c SWM181_cordic.c SWM181_div.c SWM181_dma.c SWM181_flash.c SWM181_irqmux.c SWM181_port.c SWM181_sdadc.c SWM181_slcd.c SWM181_spi.c SWM181_cache.c
  group CSL\CMSIS
    ../../SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM181.c
    ../../SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM181.s
