# Keil uVision project uCOS-II.uvprojx, settings and files
target SWM181 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.2.0.8
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: uCOS-II
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: ..\..\SWM181_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM181_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM181_StdPeriph_Driver\CSL\SWM181_StdPeriph_Driver;.\APP;.\APP\uCOS;.\APP\uCOS\Ports\ARMv6-M\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./app/: main.c
  group uCOS
    ./APP/uCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS\Port
    ./APP/uCOS/Ports/ARMv6-M/: os_cpu_c.c
    ./APP/uCOS/Ports/ARMv6-M/ARM/: os_cpu_a.asm
  group CSL\StdPD
    ../../SWM181_StdPeriph_Driver/CSL/SWM181_StdPeriph_Driver/: SWM181_adc.c SWM181_cmp.c SWM181_exti.c SWM181_gpio.c SWM181_i2c.c SWM181_pwm.c SWM181_timr.c SWM181_uart.c SWM181_wdt.c SWM181_can.c SWM181_cordic.c SWM181_div.c SWM181_dma.c SWM181_flash.c SWM181_irqmux.c SWM181_port.c SWM181_sdadc.c SWM181_slcd.c SWM181_spi.c SWM181_cache.c
  group CSL\CMSIS
    ../../SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM181.c
    ../../SWM181_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM181.s
